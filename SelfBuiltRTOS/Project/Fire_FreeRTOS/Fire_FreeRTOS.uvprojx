# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target FreeRTOS-Nano (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\FreeRTOS\Source\include;..\..\FreeRTOS\Source\portable\RVDS\ARM_CM4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../../User/: task_demo.c
  group FreeRTOS/Ports
    ../../FreeRTOS/Source/portable/RVDS/ARM_CM4/: port.c
  group FreeRTOS/Sources
    ../../FreeRTOS/Source/: list.c task.c
    ../../FreeRTOS/Source/include/: list.h portmacro.h FreeRTOSConfig.h projdefs.h rtdef.h task.h FreeRTOS.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
