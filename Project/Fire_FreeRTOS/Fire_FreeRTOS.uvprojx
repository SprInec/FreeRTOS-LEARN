# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target FreeRTOS-Nano (6210000::V6.21::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\FreeRTOS\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../../User/: main.c
  group FreeRTOS/Sources
    ../../FreeRTOS/Source/: list.c
  group doc
    ../../Doc/: readme.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.3
